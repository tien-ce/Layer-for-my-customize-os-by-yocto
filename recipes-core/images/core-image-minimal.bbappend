IMAGE_INSTALL:append = " hello openssh"