IMAGE_INSTALL:append = " hello iw wpa-supplicant openssh linux-firmware"